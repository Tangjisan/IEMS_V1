# Keil uVision project IEMS_V1.uvprojx, settings and files
target IEMS_V1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: IEMS_V1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .;../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;.cmsis/include;RTE/_IEMS_V1;../Core/Task;../Drivers/Hardware;../Drivers/Hardware/sensor_BMP280;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src
  memory RVCT1: ROM 0x8000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/Task
    ../Core/Task/: Task_test_1.cpp Task_test_1.h 00_cpp_main.cpp 00_cpp_main.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/Hardware
    ../Drivers/Hardware/: OLED.c sensor_AHT20.cpp sensor_SGP30.cpp sensor_BMP280.cpp sensor_common_def.cpp sensor_BH1750.cpp sensor_PMS5003.cpp Encoder.cpp
  group Drivers/Hardware/sensor_BMP280
    ../Drivers/Hardware/sensor_BMP280/: bmp2.c bmp2_common.c
  group Application/User/FATFS/Target
    ./: 
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ./: 
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ./: 
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 6.1.0
